# Keil uVision project MY-NW-PROJ.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: UART_MAIN +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Compare_Response.c delay.c GSM_Functionality.c initialization.c UART_Functionality.c
